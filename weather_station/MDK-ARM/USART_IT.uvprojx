# Keil uVision project USART_IT.uvprojx, settings and files
target USART_IT_Debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USART_IT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F003x8,BME280
  c include: ..\Drivers\CMSIS\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Drivers\BSP\PY32F003xx_Start_Kit;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Firmware\Inc;..\Hardware\Inc;..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f003xx.s
    ../User/Src/: system_py32f0xx.c
  group Application/User
    ../User/Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
  group Firmware
    ../Firmware/Src/: i2c_for_gdkg.c modbus.c USART1_RS485.c usart2_echo.c
  group Hardware
    ../Hardware/Src/: AS5600.c bme280.c gdkg.c MAX44009_H.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_dma.c py32f0xx_hal_pwr.c py32f0xx_hal_uart.c py32f0xx_hal_cortex.c py32f0xx_hal_i2c.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c
  group Doc
    ../: readme.txt
target USART_IT_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(8000000) ELITTLE
  output: USART_IT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F003x8
  c include: ..\..\..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F003xx_Start_Kit;..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.6.0
